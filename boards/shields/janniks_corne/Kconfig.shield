## boards/shields/janniks_corne/Kconfig.shield
```kconfig
config SHIELD_JANNIKS_CORNE_DONGLE
    def_bool $(shields_list_contains,janniks_corne_dongle)
```
